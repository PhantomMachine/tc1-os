SRC_URI += "file://user_2022-07-14-12-11-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

